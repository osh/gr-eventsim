<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_sim</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dps</value></param>
<param><key>value</key><value>20.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>25e6</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_F32</value></param>
</block>
<block>
<key>eventsim_operation1</key>
<param><key>id</key><value>eventsim_operation1_0</value></param>
<param><key>fs</key><value>samp_rate</value></param>
<param><key>dps</key><value>100</value></param>
<param><key>load</key><value>20.0</value></param>
</block>
<block>
<key>eventsim_operation2</key>
<param><key>id</key><value>eventsim_operation2_0</value></param>
<param><key>fs</key><value>samp_rate</value></param>
<param><key>dps</key><value>100</value></param>
<param><key>load</key><value>30.0</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>samplehistory</key><value>256</value></param>
<param><key>eb</key><value>asap</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>tgroup</key><value></value></param>
</block>
<block>
<key>eventsim_detector</key>
<param><key>id</key><value>eventsim_detector_0</value></param>
<param><key>fs</key><value>samp_rate</value></param>
<param><key>dps</key><value>100</value></param>
<param><key>load</key><value>5.0</value></param>
</block>
<block>
<key>es_trigger_sample_timer</key>
<param><key>id</key><value>es_trigger_sample_timer_0</value></param>
<param><key>length</key><value>int(samp_rate/dps)</value></param>
<param><key>period</key><value>int(samp_rate/dps)</value></param>
<param><key>shift</key><value>10000</value></param>
<param><key>sched_dist</key><value>int(samp_rate)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>int(8e6)</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>es_trigger_sample_timer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>sample_timer_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eventsim_detector_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>eventsim_detector_0</sink_block_id><source_key>sample_timer_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eventsim_operation2_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>eventsim_operation1_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>eventsim_operation1_0</source_block_id><sink_block_id>eventsim_operation2_0</sink_block_id><source_key>type1_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>eventsim_operation2_0</source_block_id><sink_block_id>es_handler_pdu_1</sink_block_id><source_key>type2_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_handler_pdu_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>eventsim_detector_0</source_block_id><sink_block_id>eventsim_operation1_0</sink_block_id><source_key>detect_type1_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>eventsim_detector_0</source_block_id><sink_block_id>eventsim_operation2_0</sink_block_id><source_key>detect_type2_event</source_key><sink_key>handle_event</sink_key></connection>
</flow_graph>
